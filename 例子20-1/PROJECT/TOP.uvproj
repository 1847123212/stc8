# Keil uVision project TOP.uvproj, settings and files
target Source Group 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TOP +hex
  c flags: Optimize=8 SizeSpeed=1
  group APP
    ../APP/: app_cfg.h INCLUDES.H led.c led.h main.c task_manage.c task_manage.h
  group BSP
    ../BSP/: bsp.c bsp.h globalvariable.c globalvariable.h
  group uCOSII
    ../uCOSII/: ucos_ii.h uCOS_II.C STARTUP.A51 OS_SEM.C OS_Q.C OS_MUTEX.C OS_MEM.C OS_MBOX.C OS_FLAG.C OS_CPU_A.ASM OS_CPU.H OS_CFG.H My_OS_TIME.C My_OS_TASK.C My_OS_CPU_C.C My_OS_CORE.C
