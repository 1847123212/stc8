# Keil uVision project top.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: top
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    C:/Keil_v5/C51/LIB/: C51S.LIB
